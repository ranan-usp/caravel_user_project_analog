v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 120 -170 120 -140 {
lab=sw}
N 120 -140 220 -140 {
lab=sw}
N 220 -280 220 -140 {
lab=sw}
N 120 -280 120 -250 {
lab=swbd}
N 200 -320 200 -300 {
lab=GND}
N 240 -350 260 -350 {
lab=sw}
N 140 -350 160 -350 {
lab=swbd}
N 220 -350 220 -280 {
lab=sw}
N 220 -350 240 -350 {
lab=sw}
N 120 -350 140 -350 {
lab=swbd}
N 120 -350 120 -280 {
lab=swbd}
N 300 -320 300 -300 {
lab=vin}
N 170 -50 170 -10 {
lab=GND}
N 170 -140 170 -110 {
lab=sw}
N 200 -420 200 -380 {
lab=in_dummy}
N 200 -420 300 -420 {
lab=in_dummy}
N 300 -420 300 -380 {
lab=in_dummy}
N 420 -170 420 -140 {
lab=sw1}
N 420 -140 520 -140 {
lab=sw1}
N 520 -280 520 -140 {
lab=sw1}
N 420 -280 420 -250 {
lab=swb1}
N 500 -320 500 -300 {
lab=GND}
N 540 -350 560 -350 {
lab=sw1}
N 440 -350 460 -350 {
lab=swb1}
N 520 -350 520 -280 {
lab=sw1}
N 520 -350 540 -350 {
lab=sw1}
N 420 -350 440 -350 {
lab=swb1}
N 420 -350 420 -280 {
lab=swb1}
N 600 -320 600 -300 {
lab=vin}
N 470 -50 470 -10 {
lab=GND}
N 470 -140 470 -110 {
lab=sw1}
N 500 -420 500 -380 {
lab=in0}
N 500 -420 600 -420 {
lab=in0}
N 600 -420 600 -380 {
lab=in0}
N 560 -450 560 -420 {
lab=in0}
N 560 -570 560 -510 {
lab=d0}
N 740 -170 740 -140 {
lab=sw2}
N 740 -140 840 -140 {
lab=sw2}
N 840 -280 840 -140 {
lab=sw2}
N 740 -280 740 -250 {
lab=swb2}
N 820 -320 820 -300 {
lab=GND}
N 860 -350 880 -350 {
lab=sw2}
N 760 -350 780 -350 {
lab=swb2}
N 840 -350 840 -280 {
lab=sw2}
N 840 -350 860 -350 {
lab=sw2}
N 740 -350 760 -350 {
lab=swb2}
N 740 -350 740 -280 {
lab=swb2}
N 920 -320 920 -300 {
lab=vin}
N 790 -50 790 -10 {
lab=GND}
N 790 -140 790 -110 {
lab=sw2}
N 820 -420 820 -380 {
lab=in1}
N 820 -420 920 -420 {
lab=in1}
N 920 -420 920 -380 {
lab=in1}
N 880 -450 880 -420 {
lab=in1}
N 880 -570 880 -510 {
lab=d1}
N 1040 -170 1040 -140 {
lab=sw3}
N 1040 -140 1140 -140 {
lab=sw3}
N 1140 -280 1140 -140 {
lab=sw3}
N 1040 -280 1040 -250 {
lab=swb3}
N 1120 -320 1120 -300 {
lab=GND}
N 1160 -350 1180 -350 {
lab=sw3}
N 1060 -350 1080 -350 {
lab=swb3}
N 1140 -350 1140 -280 {
lab=sw3}
N 1140 -350 1160 -350 {
lab=sw3}
N 1040 -350 1060 -350 {
lab=swb3}
N 1040 -350 1040 -280 {
lab=swb3}
N 1220 -320 1220 -300 {
lab=vin}
N 1090 -50 1090 -10 {
lab=GND}
N 1090 -140 1090 -110 {
lab=sw3}
N 1120 -420 1120 -380 {
lab=in2}
N 1120 -420 1220 -420 {
lab=in2}
N 1220 -420 1220 -380 {
lab=in2}
N 1180 -450 1180 -420 {
lab=in2}
N 1180 -570 1180 -510 {
lab=d2}
N 1340 -170 1340 -140 {
lab=sw4}
N 1340 -140 1440 -140 {
lab=sw4}
N 1440 -280 1440 -140 {
lab=sw4}
N 1340 -280 1340 -250 {
lab=swb4}
N 1420 -320 1420 -300 {
lab=GND}
N 1460 -350 1480 -350 {
lab=sw4}
N 1360 -350 1380 -350 {
lab=swb4}
N 1440 -350 1440 -280 {
lab=sw4}
N 1440 -350 1460 -350 {
lab=sw4}
N 1340 -350 1360 -350 {
lab=swb4}
N 1340 -350 1340 -280 {
lab=swb4}
N 1520 -320 1520 -300 {
lab=vin}
N 1390 -50 1390 -10 {
lab=GND}
N 1390 -140 1390 -110 {
lab=sw4}
N 1420 -420 1420 -380 {
lab=in3}
N 1420 -420 1520 -420 {
lab=in3}
N 1520 -420 1520 -380 {
lab=in3}
N 1480 -450 1480 -420 {
lab=in3}
N 1480 -570 1480 -510 {
lab=d3}
N 1640 -170 1640 -140 {
lab=sw5}
N 1640 -140 1740 -140 {
lab=sw5}
N 1740 -280 1740 -140 {
lab=sw5}
N 1640 -280 1640 -250 {
lab=swb5}
N 1720 -320 1720 -300 {
lab=GND}
N 1760 -350 1780 -350 {
lab=sw5}
N 1660 -350 1680 -350 {
lab=swb5}
N 1740 -350 1740 -280 {
lab=sw5}
N 1740 -350 1760 -350 {
lab=sw5}
N 1640 -350 1660 -350 {
lab=swb5}
N 1640 -350 1640 -280 {
lab=swb5}
N 1820 -320 1820 -300 {
lab=vin}
N 1690 -50 1690 -10 {
lab=GND}
N 1690 -140 1690 -110 {
lab=sw5}
N 1720 -420 1720 -380 {
lab=in4}
N 1720 -420 1820 -420 {
lab=in4}
N 1820 -420 1820 -380 {
lab=in4}
N 1780 -450 1780 -420 {
lab=in4}
N 1780 -570 1780 -510 {
lab=d4}
N 1960 -170 1960 -140 {
lab=sw6}
N 1960 -140 2060 -140 {
lab=sw6}
N 2060 -280 2060 -140 {
lab=sw6}
N 1960 -280 1960 -250 {
lab=swb6}
N 2040 -320 2040 -300 {
lab=GND}
N 2080 -350 2100 -350 {
lab=sw6}
N 1980 -350 2000 -350 {
lab=swb6}
N 2060 -350 2060 -280 {
lab=sw6}
N 2060 -350 2080 -350 {
lab=sw6}
N 1960 -350 1980 -350 {
lab=swb6}
N 1960 -350 1960 -280 {
lab=swb6}
N 2140 -320 2140 -300 {
lab=vin}
N 2010 -50 2010 -10 {
lab=GND}
N 2010 -140 2010 -110 {
lab=sw6}
N 2040 -420 2040 -380 {
lab=in5}
N 2040 -420 2140 -420 {
lab=in5}
N 2140 -420 2140 -380 {
lab=in5}
N 2100 -450 2100 -420 {
lab=in5}
N 2100 -570 2100 -510 {
lab=d5}
N 180 -330 180 -310 {
lab=vss}
N 180 -390 180 -370 {
lab=vdd}
N 280 -330 280 -310 {
lab=vss}
N 280 -390 280 -370 {
lab=vdd}
N 480 -330 480 -310 {
lab=vss}
N 480 -390 480 -370 {
lab=vdd}
N 580 -330 580 -310 {
lab=vss}
N 580 -390 580 -370 {
lab=vdd}
N 800 -330 800 -310 {
lab=vss}
N 800 -390 800 -370 {
lab=vdd}
N 900 -330 900 -310 {
lab=vss}
N 900 -390 900 -370 {
lab=vdd}
N 1100 -330 1100 -310 {
lab=vss}
N 1100 -390 1100 -370 {
lab=vdd}
N 1200 -330 1200 -310 {
lab=vss}
N 1200 -390 1200 -370 {
lab=vdd}
N 1400 -330 1400 -310 {
lab=vss}
N 1400 -390 1400 -370 {
lab=vdd}
N 1500 -330 1500 -310 {
lab=vss}
N 1500 -390 1500 -370 {
lab=vdd}
N 1700 -330 1700 -310 {
lab=vss}
N 1700 -390 1700 -370 {
lab=vdd}
N 1800 -330 1800 -310 {
lab=vss}
N 1800 -390 1800 -370 {
lab=vdd}
N 2020 -330 2020 -310 {
lab=vss}
N 2020 -390 2020 -370 {
lab=vdd}
N 2120 -330 2120 -310 {
lab=vss}
N 2120 -390 2120 -370 {
lab=vdd}
N 260 -570 260 -520 {
lab=dummy}
N 260 -460 260 -420 {
lab=in_dummy}
N 260 -570 360 -570 {
lab=dummy}
N 420 -570 690 -570 {
lab=d0}
N 750 -570 1000 -570 {
lab=d1}
N 1060 -570 1310 -570 {
lab=d2}
N 1370 -570 1610 -570 {
lab=d3}
N 1670 -570 1920 -570 {
lab=d4}
N 1980 -570 2020 -570 {
lab=d5}
N 2020 -570 2100 -570 {
lab=d5}
C {gnd.sym} 200 -300 0 0 {name=l2 lab=GND}
C {lab_wire.sym} 240 -350 0 0 {name=l3 sig_type=std_logic lab=sw}
C {lab_wire.sym} 140 -350 0 0 {name=l4 sig_type=std_logic lab=swbd
}
C {vsource.sym} 170 -80 0 0 {name=V1 value=dummy
}
C {gnd.sym} 170 -10 0 0 {name=l7 lab=GND}
C {lab_wire.sym} 300 -300 2 0 {name=l6 sig_type=std_logic lab=vin
}
C {gnd.sym} 500 -300 0 0 {name=l9 lab=GND}
C {lab_wire.sym} 540 -350 0 0 {name=l10 sig_type=std_logic lab=sw1}
C {lab_wire.sym} 440 -350 0 0 {name=l11 sig_type=std_logic lab=swb1
}
C {vsource.sym} 470 -80 0 0 {name=V2 value=d0}
C {gnd.sym} 470 -10 0 0 {name=l13 lab=GND}
C {lab_wire.sym} 600 -300 2 0 {name=l14 sig_type=std_logic lab=vin
}
C {gnd.sym} 820 -300 0 0 {name=l16 lab=GND}
C {lab_wire.sym} 860 -350 0 0 {name=l17 sig_type=std_logic lab=sw2}
C {lab_wire.sym} 760 -350 0 0 {name=l18 sig_type=std_logic lab=swb2
}
C {vsource.sym} 790 -80 0 0 {name=V3 value=d1
}
C {gnd.sym} 790 -10 0 0 {name=l20 lab=GND}
C {lab_wire.sym} 920 -300 2 0 {name=l21 sig_type=std_logic lab=vin
}
C {gnd.sym} 1120 -300 0 0 {name=l23 lab=GND}
C {lab_wire.sym} 1160 -350 0 0 {name=l24 sig_type=std_logic lab=sw3}
C {lab_wire.sym} 1060 -350 0 0 {name=l25 sig_type=std_logic lab=swb3
}
C {vsource.sym} 1090 -80 0 0 {name=V4 value=d2}
C {gnd.sym} 1090 -10 0 0 {name=l27 lab=GND}
C {lab_wire.sym} 1220 -300 2 0 {name=l28 sig_type=std_logic lab=vin
}
C {gnd.sym} 1420 -300 0 0 {name=l30 lab=GND}
C {lab_wire.sym} 1460 -350 0 0 {name=l31 sig_type=std_logic lab=sw4}
C {lab_wire.sym} 1360 -350 0 0 {name=l32 sig_type=std_logic lab=swb4
}
C {vsource.sym} 1390 -80 0 0 {name=V5 value=d3
}
C {gnd.sym} 1390 -10 0 0 {name=l34 lab=GND}
C {lab_wire.sym} 1520 -300 2 0 {name=l35 sig_type=std_logic lab=vin
}
C {gnd.sym} 1720 -300 0 0 {name=l37 lab=GND}
C {lab_wire.sym} 1760 -350 0 0 {name=l38 sig_type=std_logic lab=sw5}
C {lab_wire.sym} 1660 -350 0 0 {name=l39 sig_type=std_logic lab=swb5
}
C {vsource.sym} 1690 -80 0 0 {name=V6 value=d4
}
C {gnd.sym} 1690 -10 0 0 {name=l41 lab=GND}
C {lab_wire.sym} 1820 -300 2 0 {name=l42 sig_type=std_logic lab=vin
}
C {gnd.sym} 2040 -300 0 0 {name=l44 lab=GND}
C {lab_wire.sym} 2080 -350 0 0 {name=l45 sig_type=std_logic lab=sw6}
C {lab_wire.sym} 1980 -350 0 0 {name=l46 sig_type=std_logic lab=swb6
}
C {vsource.sym} 2010 -80 0 0 {name=V7 value=d5
}
C {gnd.sym} 2010 -10 0 0 {name=l48 lab=GND}
C {lab_wire.sym} 2140 -300 2 0 {name=l49 sig_type=std_logic lab=vin
}
C {devices/code.sym} 900 -700 0 0 {
name=CORNERS 
only_toplevel=true 
format="tcleval( @value )"
spice_ignore="tcleval($cmdline_ignore)"
value="* FET CORNERS
.include \\\\$::SKYWATER_MODELS\\\\/models/corners/tt.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ff.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ss.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/sf.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/fs.spice

* TT + R + C
*.include \\\\$::SKYWATER_MODELS\\\\/corners/tt_rmax_cmax.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/tt_rmin_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/tt_rmax_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/tt_rmin_cmax.spice

* FF + R + C
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ff_rmax_cmax.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ff_rmin_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ff_rmax_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ff_rmin_cmax.spice


* SS + R + C
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ss_rmax_cmax.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ss_rmin_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ss_rmax_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/ss_rmin_cmax.spice

* SF + R + C
*.include \\\\$::SKYWATER_MODELS\\\\/corners/sf_rmax_cmax.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/sf_rmin_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/sf_rmax_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/sf_rmin_cmax.spice

* FS + R + C
*.include \\\\$::SKYWATER_MODELS\\\\/corners/fs_rmax_cmax.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/fs_rmin_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/fs_rmax_cmin.spice
*.include \\\\$::SKYWATER_MODELS\\\\/corners/fs_rmin_cmax.spice
"}
C {code_shown.sym} 2600 -580 0 0 {name=s1 only_toplevel=false value="
.option wnflag=1
.option plotwinsize=0
Vin vin 0 dc PULSE(0 1 0 12.8u 0 0.2u 13u)
*Vin vin 0 1.8
VDD vdd 0 1.8
VSS vss 0 0

.param dummy=0
.param d5=1
.param d4=0
.param d3=0
.param d2=0
.param d1=0
.param d0=0
.param para=5

.control
save all
tran 1u 13u

meas tran output find v(d5) at=13u

wrdata out output
print output
.endc
"}
C {devices/code.sym} 1040 -710 0 0 {
name=STDCELLS 
only_toplevel=false 
format="tcleval( @value )"
value="

.include \\\\$::SKYWATER_STDCELLS\\\\/cells/inv/sky130_fd_sc_hd__inv_2.spice"
}
C {sar_10b/unitcap/unitcap.sym} 540 -440 0 0 {name=x9}
C {sar_10b/unitcap/unitcap.sym} 860 -440 0 0 {name=x10[1:0]}
C {sar_10b/unitcap/unitcap.sym} 1160 -440 0 0 {name=x11[3:0]}
C {sar_10b/unitcap/unitcap.sym} 1460 -440 0 0 {name=x12[7:0]}
C {sar_10b/unitcap/unitcap.sym} 1760 -440 0 0 {name=x13[15:0]}
C {sar_10b/unitcap/unitcap.sym} 2080 -440 0 0 {name=x14[31:0]}
C {switches/my_passgate.sym} 0 -210 0 0 {name=x10}
C {lab_wire.sym} 180 -320 0 0 {name=l1 sig_type=std_logic lab=vss}
C {lab_wire.sym} 180 -380 0 0 {name=l51 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 100 -210 0 0 {name=x11}
C {lab_wire.sym} 280 -320 0 0 {name=l5 sig_type=std_logic lab=vss}
C {lab_wire.sym} 280 -380 0 0 {name=l8 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 300 -210 0 0 {name=x12}
C {lab_wire.sym} 480 -320 0 0 {name=l12 sig_type=std_logic lab=vss}
C {lab_wire.sym} 480 -380 0 0 {name=l15 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 400 -210 0 0 {name=x13}
C {lab_wire.sym} 580 -320 0 0 {name=l19 sig_type=std_logic lab=vss}
C {lab_wire.sym} 580 -380 0 0 {name=l22 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 620 -210 0 0 {name=x14}
C {lab_wire.sym} 800 -320 0 0 {name=l26 sig_type=std_logic lab=vss}
C {lab_wire.sym} 800 -380 0 0 {name=l29 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 720 -210 0 0 {name=x15}
C {lab_wire.sym} 900 -320 0 0 {name=l33 sig_type=std_logic lab=vss}
C {lab_wire.sym} 900 -380 0 0 {name=l36 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 920 -210 0 0 {name=x16}
C {lab_wire.sym} 1100 -320 0 0 {name=l40 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1100 -380 0 0 {name=l43 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1020 -210 0 0 {name=x17}
C {lab_wire.sym} 1200 -320 0 0 {name=l47 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1200 -380 0 0 {name=l52 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1220 -210 0 0 {name=x18}
C {lab_wire.sym} 1400 -320 0 0 {name=l53 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1400 -380 0 0 {name=l54 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1320 -210 0 0 {name=x19}
C {lab_wire.sym} 1500 -320 0 0 {name=l55 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1500 -380 0 0 {name=l56 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1520 -210 0 0 {name=x20}
C {lab_wire.sym} 1700 -320 0 0 {name=l57 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1700 -380 0 0 {name=l58 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1620 -210 0 0 {name=x21}
C {lab_wire.sym} 1800 -320 0 0 {name=l59 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1800 -380 0 0 {name=l60 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1840 -210 0 0 {name=x22}
C {lab_wire.sym} 2020 -320 0 0 {name=l61 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2020 -380 0 0 {name=l62 sig_type=std_logic lab=vdd}
C {switches/my_passgate.sym} 1940 -210 0 0 {name=x23}
C {lab_wire.sym} 2120 -320 0 0 {name=l63 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2120 -380 0 0 {name=l64 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2070 -570 0 1 {name=l65 sig_type=std_logic lab=d5}
C {xschem_sky130/sky130_stdcells/inv_2.sym} 1960 -210 3 0 {name=x7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {xschem_sky130/sky130_stdcells/inv_2.sym} 1640 -210 3 0 {name=x1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {xschem_sky130/sky130_stdcells/inv_2.sym} 1340 -210 3 0 {name=x2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {xschem_sky130/sky130_stdcells/inv_2.sym} 1040 -210 3 0 {name=x3 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {xschem_sky130/sky130_stdcells/inv_2.sym} 740 -210 3 0 {name=x4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {xschem_sky130/sky130_stdcells/inv_2.sym} 420 -210 3 0 {name=x5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {xschem_sky130/sky130_stdcells/inv_2.sym} 120 -210 3 0 {name=x6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sar_10b/unitcap/unitcap.sym} 240 -450 0 0 {name=x8}
C {res.sym} 390 -570 1 0 {name=R7
value=para
footprint=1206
device=resistor
m=1}
C {res.sym} 720 -570 1 0 {name=R1
value=para
footprint=1206
device=resistor
m=1}
C {res.sym} 1030 -570 1 0 {name=R2
value=para
footprint=1206
device=resistor
m=1}
C {res.sym} 1340 -570 1 0 {name=R3
value=para
footprint=1206
device=resistor
m=1}
C {res.sym} 1640 -570 1 0 {name=R4
value=para
footprint=1206
device=resistor
m=1}
C {res.sym} 1950 -570 1 0 {name=R5
value=para
footprint=1206
device=resistor
m=1}
C {lab_wire.sym} 540 -420 0 0 {name=l66 sig_type=std_logic lab=in0}
C {lab_wire.sym} 860 -420 0 0 {name=l67 sig_type=std_logic lab=in1}
C {lab_wire.sym} 1160 -420 0 0 {name=l68 sig_type=std_logic lab=in2}
C {lab_wire.sym} 1460 -420 0 0 {name=l69 sig_type=std_logic lab=in3}
C {lab_wire.sym} 1760 -420 0 0 {name=l70 sig_type=std_logic lab=in4}
C {lab_wire.sym} 2080 -420 0 0 {name=l71 sig_type=std_logic lab=in5}
C {lab_wire.sym} 240 -420 0 0 {name=l72 sig_type=std_logic lab=in_dummy}
C {lab_wire.sym} 260 -570 0 0 {name=l50 sig_type=std_logic lab=dummy}
C {lab_wire.sym} 560 -570 0 0 {name=l73 sig_type=std_logic lab=d0}
C {lab_wire.sym} 880 -570 0 0 {name=l74 sig_type=std_logic lab=d1}
C {lab_wire.sym} 1180 -570 0 0 {name=l75 sig_type=std_logic lab=d2}
C {lab_wire.sym} 1480 -570 0 0 {name=l76 sig_type=std_logic lab=d3}
C {lab_wire.sym} 1780 -570 0 0 {name=l77 sig_type=std_logic lab=d4}
